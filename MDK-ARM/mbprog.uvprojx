# Keil uVision project mbprog.uvprojx, settings and files
target mbprog (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F042F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: mbprog +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_cdc_if.c main.c usbd_desc.c usb_device.c stm32f0xx_hal_msp.c usbd_conf.c stm32f0xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_gpio.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c.c
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
software components: CMSIS:CORE 4.1.0
